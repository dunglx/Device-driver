## kernel/drivers/dunglx/Kconfig
```kconfig
config LEDS_GPIO_SYSFS
	bool
	help
	  DungLX test thu viec su dung sysfs de dieu khien cac led gpio.
```
